<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BLE_Update_Master.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>BUILD_ALL</name>
            <member>
                <project>BLE_SensorDemo_Central</project>
                <configuration>HigherApp_OTA</configuration>
            </member>
            <member>
                <project>BLE_SensorDemo_Central</project>
                <configuration>LowerApp_OTA</configuration>
            </member>
            <member>
                <project>BLE_SensorDemo_Central</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>BLE_SensorDemo_Central</project>
                <configuration>Use_OTA_ServiceManager</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
